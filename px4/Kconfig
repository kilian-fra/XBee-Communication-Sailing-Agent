## px4/Kconfig
```kconfig
menuconfig MODULES_COMMUNICATION
	bool "communication"
	default n
	---help---
		Enable support for communication
```
